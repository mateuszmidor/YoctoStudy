# base.bbclass is inherited by every recipe so it is a must

# add do_build task
addtask build
